# IAR project adc_data_logger_launchpad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 4
  ICCARM.CCDefines: DEVICE_FAMILY=cc13x2_cc26x2; DeviceFamily_CC26X2
  ICCARM.CCIncludePath2: C:\ti\simplelink_cc13xx_cc26xx_sdk_8_30_01_01\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_data_logger_launchpad.srec
  ILINK.IlinkOutputFile: adc_data_logger_launchpad.out
  ILINK.IlinkAdditionalLibs: C:\ti\simplelink_cc13xx_cc26xx_sdk_8_30_01_01\source\ti\devices\cc13x2_cc26x2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../source/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_none.h main.c
  group sdk_files__do_not_edit
    C:/ti/simplelink_cc13xx_cc26xx_sdk_8_30_01_01/source/ti/devices/cc13x2_cc26x2/startup_files/: startup_iar.c ccfg.c
