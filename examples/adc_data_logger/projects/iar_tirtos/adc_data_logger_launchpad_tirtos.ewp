# IAR project adc_data_logger_launchpad_tirtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEVICE_FAMILY=cc13x2_cc26x2; DeviceFamily_CC26X2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb
  ICCARM.CCIncludePath2: $PROJ_DIR$; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/kernel/tirtos7/packages; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/posix/iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_data_logger_launchpad_tirtos.srec
  ILINK.IlinkOutputFile: adc_data_logger_launchpad_tirtos.out
  ILINK.IlinkIcfFile: $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/examples/rtos/CC26X2R1_LAUNCHXL/drivers/empty/tirtos7/iar/cc13x2_cc26x2_tirtos7.icf
  ILINK.IlinkExtraOptions: -L $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source; -L $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/kernel/tirtos7/packages; -f ti_utils_build_linker.cmd.genlibs; $SIMPLELINK_CC13XX_CC26XX_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M33; --fpu VFPv5_sp
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: ex_common.syscfg ti_devices_config.c ti_drivers_config.c ti_drivers_config.h ti_sysbios_config.c ti_sysbios_config.h
    ../../source/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_tirtos.h main_tirtos.c
